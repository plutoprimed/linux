## drivers/iio/generic_reg/Kconfig
```kconfig
menu "IIO generic register driver"
	depends on IIO

config IIO_GENERIC_REG
	tristate "Generic register driver"
	help
	  Driver.

endmenu
```
